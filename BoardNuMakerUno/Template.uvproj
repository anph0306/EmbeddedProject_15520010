# Keil uVision project Template.uvproj, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC131SD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x10FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 uC99=1
  c include: ..\Template;..\NUC140BSP\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\NUC140BSP\NuvotonPlatform_Keil\Include;..\NUC140BSP\NuvotonPlatform_Keil\Include\Driver;..\NUC140BSP\CMSIS\CM0\CoreSupport;..\NUC140BSP\NuvotonPlatform_Keil\Include\NUC1xx-LB_002
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../NUC140BSP/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../NUC140BSP/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../NUC140BSP/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ./: main.c
    ../NUC140BSP/NuvotonPlatform_Keil/Src/NUC1xx-LB_002/: ScanKey.c
  group Library files
    ../NUC140BSP/NuvotonPlatform_Keil/Src/Driver/: DrvGPIO.c DrvUART.c DrvSYS.c retarget.c
